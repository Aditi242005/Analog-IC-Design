v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {vcvs.sym} -180 30 0 0 {name=E1 value=3}
C {vcvs.sym} 130 30 0 0 {name=E2 value=3}
