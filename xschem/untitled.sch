** sch_path: xschem/untitled.sch
**.subckt untitled
E1 net1 net3 net4 net5 1000
E2 net6 net7 net2 net3 1
R1 net2 net1 1k m=1
C1 net2 net3 1p m=1
**.ends
.end
